<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Fs</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Sps</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>b_PSD</key>
<param><key>id</key><value>b_PSD_0</value></param>
<param><key>Amp</key><value>1</value></param>
<param><key>samp_rate_audio</key><value>Fs</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>N</key><value>1024</value></param>
<param><key>Ensayos</key><value>1000000</value></param>
<param><key>Titulo</key><value>'PSD. QT GUI b_PSD'</value></param>
<param><key>Ymax</key><value>8e-6</value></param>
</block>
<block>
<key>b_binary_bipolar_source_f</key>
<param><key>id</key><value>b_binary_bipolar_source_f_0</value></param>
<param><key>Am</key><value>1</value></param>
<param><key>Spb</key><value>Sps</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>Fs</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>N</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label1</key><value>.</value></param>
<param><key>width1</key><value>4</value></param>
<param><key>name</key><value>"PSD.  QT GUI Frequency Sink"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>-20</value></param>
<param><key>ymin</key><value>-90</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>vs</value></param>
<param><key>stream_id</key><value>P1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>vso</value></param>
<param><key>stream_id</key><value>P1</value></param>
</block>
<connection><source_block_id>b_binary_bipolar_source_f_0</source_block_id><sink_block_id>vs</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>b_PSD_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vso</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
